# Keil uVision project USER.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USER +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10X_FWLIB\inc;..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\DHT11;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\HARDWARE\TIMER;..\HARDWARE\RELAY;..\HARDWARE\WKUP;..\HARDWARE\CNT;..\HARDWARE\EXTI;..\HARDWARE\USART3;..\Utils;..\Gizwits
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10X_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/USART3/: usart3.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
